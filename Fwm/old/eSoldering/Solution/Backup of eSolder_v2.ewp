# IAR project Backup of eSolder_v2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xB ST STM32F105xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\Board; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\CMSIS; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\Core; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\Drivers; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\FreeRTOS\Source\include; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\IQ; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\Tasks; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\FreeRTOS\Source; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\UI; C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\FreeRTOS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eSolder_v2.srec
  ILINK.IlinkOutputFile: eSolder_v2.out
  ILINK.IlinkAdditionalLibs: C:\Users\EricMarina\Documents\IAR\eSolder_v2\Solution\Source\IQ\IQmathLib-cm3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Source/: errorHandlers.c main.c stationState.c stationState.h
    Source/FreeRTOS/: OSInit.c
  group Board
    Source/Board/: beep.c dryFan.c ili9341.c keyboard.c
  group CMSIS
    Source/CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Core
    Source/Core/: startup_stm32f105xc.s stm32f105xc.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group Drivers
    Source/Drivers/: button.c clock.c enco.c GPIO.c i2c.c lcd.c lcd_backlight.c max6675.c pwm.c pwr.c regulator.c spi.c
  group FreeRTOS
    Source/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOSConfig.h heap_4.c list.c port.c portasm.s portmacro.h queue.c tasks.c timers.c
  group IQ
    Source/IQ/: IQmathLib.h PID_GRANDO_IQ.c specificMath.c
  group Tasks
    Source/Tasks/: mainTSK.c menuTSK.c systemTSK.c tempMeasTSK.c
  group UI
    Source/UI/: Fonts.h Image.h UI.c
  group UI/Fonts
    Source/UI/Fonts/: Arial.c Courier_New.c DS_Digital.c DS_Digital_Small.c specific_symbol.c
